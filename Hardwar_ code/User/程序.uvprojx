# Keil uVision project 程序.uvprojx, settings and files
target Target 1 (5060960::V5.06 update 7 (build 960)::.\ARM_Compiler_5.06u7)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: 程序 +hex
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1
  c define: STM32F10X_MD,USE_STDPERIPH_DRIVER
  c include: ..\CMSIS;..\System\delay;..\System\sys;..\System\usart;..\User;..\Libraries\inc;..\Driver;..\System\kalman;..\System\pid;..\System\pwm
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group CMSIS
    ../CMSIS/: core_cm3.c startup_stm32f10x_md.s
  group FWLIB
    ../Libraries/src/: misc.c stm32f10x_adc.c stm32f10x_exti.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_flash.c stm32f10x_i2c.c
  group DRIVER
    ../Driver/: adc.c gpio.c OLED_I2C.c timer.c dht11.c esp8266.c
  group USER
    ./: main.c stm32f10x_it.c system_stm32f10x.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../System/usart/: usart1.c
    ../System/pid/: PID.c
    ../System/pwm/: pwm.c
    ../System/kalman/: kalman_filter.c
